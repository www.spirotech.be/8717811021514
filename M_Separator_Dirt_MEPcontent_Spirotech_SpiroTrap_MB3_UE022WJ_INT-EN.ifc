Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_UE022WJ_INT-EN.ifc
Time: 2025-08-05T18:28:07+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_2013100_1 | SINK
OutPort_2013100_2 | SOURCE

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN:UE022WJ, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN:UE022WJ:2013100
In: F00
Type - Material: Color RGB 055-055-055, Color RGB 168-128-048, Color RGB 235-235-235
Type - Other - Category: Pipe Accessories; Arm Length: 80.5 mm; Arrow Distance: 28.5 mm; Ball Radius: 25 mm; Center Diatance: 57 mm; Chamfer Distance: 12.5 mm; Connection Diameter: 22 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN; Front End Diameter: 29 mm; Front End Length: 110 mm; Left Cylinder Length: 30 mm; Left Length: 22.5 mm; Left Line Length: 36 mm; Nut Depth: 32 mm; Nut Height: 37 mm; Nut Length: 14 mm; Nut Offset: 1 mm; Right Cylinder Length: 38 mm; Right Length: 30.5 mm; Right Line Length: 44 mm; Support Height: 1.5 mm; Void Diameter: 14 mm; Void Length: 6 mm; Washer Diameter: 31.5 mm; Washer Length: 15 mm; Washer Offset: 0 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Angle: 0 deg; Connection Nominal Diameter: 22 mm; Connection Outer Diameter: 22 mm; D: 37 mm; Hh: 148.5 mm; Hv: 176 mm; L: 110 mm; M: 122.5 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Particle and dirt separator - Brass 22 mm - Magnet; Article Type: UE022WJ; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Particle and dirt separator - Brass 22 mm - Magnet; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811018422; Manufacturer: Spirotech; Manufacturer Art. No.: UE022WJ; Manufacturer URL: https://www.spirotech.com/8717811018422; MEPcontent Class: SEPARATOR_DIRT; Model: UE022WJ; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: UE022WJ; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Brass Yellow: Color RGB 168-128-048; White: Color RGB 235-235-235
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.00247 m3/s
Type - Mechanical - Flow - Kv: 0.00247 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: UE022WJ; sets with these values: 2
Other - Angle: 0 deg; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN: UE022WJ; Type: UE022WJ; Type Id: 2012839
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.000107083 m2; Maximum Size: 22 mm; Minimum Size: 22 mm; Volume: 0.0010231 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
