Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_UE028WJ_INT-EN.ifc
Time: 2025-08-05T18:28:10+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_2013341_1 | SINK
OutPort_2013341_2 | SOURCE

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN:UE028WJ, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN:UE028WJ:2013341
In: F00
Type - Material: Color RGB 055-055-055, Color RGB 168-128-048, Color RGB 235-235-235
Type - Other - Category: Pipe Accessories; Arm Length: 84.5 mm; Arrow Distance: 34 mm; Ball Radius: 25 mm; Center Diatance: 57 mm; Chamfer Distance: 15.5 mm; Connection Diameter: 28 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN; Front End Diameter: 35 mm; Front End Length: 111.999 mm; Left Cylinder Length: 30 mm; Left Length: 23.5 mm; Left Line Length: 35 mm; Nut Depth: 39 mm; Nut Height: 45 mm; Nut Length: 12 mm; Nut Offset: 2 mm; Right Cylinder Length: 38 mm; Right Length: 31.5 mm; Right Line Length: 43 mm; Support Height: 2.5 mm; Void Diameter: 17.5 mm; Void Length: 8 mm; Washer Diameter: 38.5 mm; Washer Length: 17 mm; Washer Offset: 0 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Angle: 0 deg; Connection Nominal Diameter: 28 mm; Connection Outer Diameter: 28 mm; D: 44.9995 mm; Hh: 148.5 mm; Hv: 176.998 mm; L: 111.999 mm; M: 126.5 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Particle and dirt separator - Brass 28 mm - Magnet; Article Type: UE028WJ; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Particle and dirt separator - Brass 28 mm - Magnet; EMCS Version: 2.0; ETIM Article Class: EC010260; Family Version: 11.14; GLN: 8717811000007; GTIN: 8717811018439; Manufacturer: Spirotech; Manufacturer Art. No.: UE028WJ; Manufacturer URL: https://www.spirotech.com/8717811018439; MEPcontent Class: SEPARATOR_DIRT; Model: UE028WJ; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: UE028WJ; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Brass Yellow: Color RGB 168-128-048; White: Color RGB 235-235-235
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0.00283 m3/s
Type - Mechanical - Flow - Kv: 0.00283 m3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: UE028WJ; sets with these values: 2
Other - Angle: 0 deg; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_MB3_INT-EN: UE028WJ; Type: UE028WJ; Type Id: 2012841
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.000107083 m2; Maximum Size: 28 mm; Minimum Size: 28 mm; Volume: 0.00107409 m3
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Insulation - Insulation Thickness: 0 mm
